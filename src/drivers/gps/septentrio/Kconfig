## src/drivers/gps/septentrio/Kconfig
```kconfig
menuconfig DRIVERS_GPS_SEPTENTRIO
	bool "septentrio"
	default n
	---help---
		Enable support for Septentrio receivers
```
